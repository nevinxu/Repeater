# Keil uVision project Repeater_Project.uvproj, settings and files
target Repeater_Project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: wifi_project
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,
  c include: ..\App;..\Bsp;..\Library\CM3;..\Library\STM32_Lib\inc;..\\OS-uCOSII\core;..\\OS-uCOSII\port;..;../Library;../driver;..\Library\wlan
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32F10x_CM3
    ../Library/CM3/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../Library/CM3/startup/: startup_stm32f10x_md.s
  group APP
    ../App/: stm32f10x_it.c app.c wifi_application.c DataProcess.c LcdDisplay.c
  group BSP
    ../Bsp/: bsp.c
  group uCOSII_source
    ../OS-uCOSII/core/: os_core.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../OS-uCOSII/port/: os_cpu_c.c os_cpu_a.asm
  group driver
    ../driver/: cc1101.c
    ../driver/w25x40/: spi_flash.c
    ../driver/LCD/: UC1701X.c
  group wlan
    ../Library/wlan/: cc3000_common.c cc3000spi.c evnt_handler.c hci.c netapp.c nvmem.c security.c socket.c wlan.c
  group std
    ../Library/STM32_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ReadMe
    ../: readme.txt
