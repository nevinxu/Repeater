# Keil uVision project ucosii.uvproj, settings and files
target ucosii_lib (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ucosii (library)
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: ..\..\OS-uCOSII\core;..\..\App;..\..\OS-uCOSII\port;..\..\Bsp
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ../../OS-uCOSII/core/: os_core.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../../OS-uCOSII/port/: os_cpu_a.asm os_cpu_c.c
